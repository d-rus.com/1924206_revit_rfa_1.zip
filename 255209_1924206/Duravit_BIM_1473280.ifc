Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: durastyle_toilet_wall_mounted_255209.ifc
Time: 2017-11-15T14:51:25
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: DuraStyle Toilet wall mounted 255209
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): DuraStyle Toilet wall mounted 255209; SKU (BO_prodsku): durastyle-toilet-wall-mounted-255209; ManufacturName (BO_Manufac): DURAVIT; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): DuraStyle; ProductGroup (BO_prodgroup): Toilet wall mounted; PublishDate (BO_publisdat): 1/11/2017; EditionNumber (BO_edinum): 1; Width (BO_width): 370; Height (BO_height): 0; Depth (BO_depth): 540; Weight (BO_weight): 23; QR (BO_boqrurl): http://bimobject.com/duravit/product/durastyle-toilet-wall-mounted-255209; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/durastyle-toilet-wall-mounted-255209; ProductUrl (BO_producturl): http://pro.duravit.com/255209; InstallationInstructions (BO_montins): http://pro.duravit.com/255209; ProductCertification (BO_prodcert): http://pro.duravit.com/255209; TechnicalDescription (BO_techcert): http://pro.duravit.com/255209; BimObjectCategory (BO_bocat): Toilets; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7216; Uniclass14Description (BO_uniclass_1_4_desc): Toilets; Uniclass20Code (BO_uniclass_2_0_code): SS-35-65-90; Uniclass20Description (BO_uniclass_2_0_desc): Toilet Systems; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_93; Uniclass2015Description (BO_uniclass2015_desc): Urinal and WC fittings; NBSReference (BO_nbs_ref): 35-65-90; NBSReferenceDescription (BO_nbs_desc): Toilet Systems; OmniClassCode (BO_omniclass_code): 23-31 19 00; OmniClassDescription (BO_omniclass_name): Toilets; MasterFormat2014Code (BO_masterformat2014_code): 01 52 19; MasterFormat2014Description (BO_masterformat2014_name): Sanitary Facilities; UniFormat2Code (BO_uniformat2_code): D2030; UniFormat2Description (BO_uniformat2_name): Sanitary Waste; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
